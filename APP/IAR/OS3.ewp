# IAR project OS3.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: RM48L952ZWT TexasInstruments RM48L952ZWT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..; ..\..\BSP; ..\..\BSP\IAR-HCG\include; ..\..\..\..\..\Software\uC-CPU; ..\..\..\..\..\Software\uC-CPU\ARM-Cortex-A\IAR; ..\..\..\..\..\Software\uC-LIB; ..\..\..\..\..\Software\uCOS-III\Ports\ARM-Cortex-A\Generic\IAR; ..\..\..\..\..\Software\uCOS-III\Source; ..\..\..\..\..\Software\uC-Serial\Driver\TI; ..\..\..\..\..\Software\uC-Serial\Line; ..\..\..\..\..\Software\uC-Serial\OS; ..\..\..\..\..\Software\uC-Serial\Source; ..\..\..\..\..\Software\uC-Probe\Target\Communication\Generic\Source; ..\..\..\..\..\Software\uC-Probe\Target\Communication\Generic\Serial\Source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OS3.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\BSP\IAR-HCG\source\sys_link.cmd
  ILINK.IlinkProgramEntryLabel: _c_int00
  group APP
    ../: app.c app_cfg.h bsp_cfg.h cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group APP/Probe
    ../: app_probe.c app_probe.h probe_com_cfg.h
  group APP/Serial
    ../: app_serial.c app_serial.h
  group BSP
    ../../BSP/: bsp.c bsp.h bsp_int.c bsp_int.h bsp_sys.c bsp_sys.h cpu_bsp.c os_bsp.c os_bsp.h serial_bsp_rm48.c serial_bsp_rm48.h
  group BSP/IAR-HCG/include
    ../../BSP/IAR-HCG/include/: adc.h can.h crc.h dcc.h Device_header.h Device_RM48.h Device_types.h dmm.h emac.h emif.h esm.h fee_interface.h gio.h hal_stdtypes.h het.h htu.h hw_emac.h hw_emac_ctrl.h hw_mdio.h hw_reg_access.h hw_usb.h i2c.h lin.h mdio.h MemMap.h mibspi.h phy_dp83640.h pinmux.h pom.h reg_adc.h reg_can.h reg_crc.h reg_dcc.h reg_dma.h reg_dmm.h reg_efc.h reg_emif.h reg_esm.h reg_flash.h reg_gio.h reg_het.h reg_htu.h reg_i2c.h reg_lin.h reg_mibspi.h reg_pbist.h reg_pcr.h reg_pinmux.h reg_pmm.h reg_pom.h reg_rti.h reg_rtp.h reg_sci.h reg_spi.h reg_stc.h reg_system.h reg_tcram.h reg_vim.h rti.h rtp.h sci.h spi.h std_nhet.h sys_common.h sys_core.h sys_dma.h sys_mpu.h sys_pcr.h sys_pmm.h sys_pmu.h sys_selftest.h sys_vim.h system.h ti_fee.h ti_fee_cfg.h ti_fee_types.h usb-ids.h usb.h usb_serial_structs.h usbcdc.h usbdcdc.h usbdevice.h usbdevicepriv.h usblib.h
  group BSP/IAR-HCG/source
    ../../BSP/IAR-HCG/source/: dabort.asm esm.c notification.c pinmux.c sys_core.asm sys_dma.c sys_intvecs.asm sys_link.cmd sys_main.c sys_mpu.asm sys_pcr.c sys_phantom.c sys_pmm.c sys_pmu.asm sys_selftest.c sys_startup.c sys_vim.c system.c
  group uC-CPU
    ../../../../../Software/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group uC-CPU/ARM-Cortex-A/IAR
    ../../../../../Software/uC-CPU/ARM-Cortex-A/IAR/: cpu.h cpu_a.asm
  group uC-LIB
    ../../../../../Software/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC-Probe/Target/Communication/Generic/OS/uCOS-III
    ../../../../../Software/uC-Probe/Target/Communication/Generic/OS/uCOS-III/: probe_com_os.c
  group uC-Probe/Target/Communication/Generic/Serial/OS/uCOS-III
    ../../../../../Software/uC-Probe/Target/Communication/Generic/Serial/OS/uCOS-III/: probe_serial_os.c
  group uC-Probe/Target/Communication/Generic/Serial/Source
    ../../../../../Software/uC-Probe/Target/Communication/Generic/Serial/Source/: probe_serial.c probe_serial.h
  group uC-Probe/Target/Communication/Generic/Source
    ../../../../../Software/uC-Probe/Target/Communication/Generic/Source/: probe_com.c probe_com.h
  group uC-Serial/Driver/TI
    ../../../../../Software/uC-Serial/Driver/TI/: serial_drv_rm48.c serial_drv_rm48.h
  group uC-Serial/Line
    ../../../../../Software/uC-Serial/Line/: serial_line_dflt.c serial_line_dflt.h serial_line_probe.c serial_line_probe.h serial_line_tty.c serial_line_tty.h
  group uC-Serial/OS
    ../../../../../Software/uC-Serial/OS/: serial_os.h
  group uC-Serial/OS/uCOS-III
    ../../../../../Software/uC-Serial/OS/uCOS-III/: serial_os.c
  group uC-Serial/Source
    ../../../../../Software/uC-Serial/Source/: serial.c serial.h serial_buf.c serial_buf.h serial_type.h
  group uCOS-III/Ports/ARM-Cortex-A/Generic/IAR
    ../../../../../Software/uCOS-III/Ports/ARM-Cortex-A/Generic/IAR/: os_cpu.h os_cpu_a_vfp-d16.asm os_cpu_a_vfp-d32.asm os_cpu_a_vfp-none.asm os_cpu_c.c
  group uCOS-III/Source
    ../../../../../Software/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
